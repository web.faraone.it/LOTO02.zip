Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0, QuantityTakeOffAddOnView]
File name: REF_LOTO02
Time: 2017-10-05T23:02:54
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150714_1515(x64) - Exporter 16.4.0.0 - Alternate UI 16.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Oct 05 23:02:54 2017 * Host: AsusFede * Database: C:\Users\Federico\AppData\Local\Temp\{7409112B-DE54-4A65-AD70-2C8BD5469EE3}\ifc * Database version: 5507 * Database creation date: Thu Oct 05 23:02:52 2017 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Thu Oct 05 23:02:52 2017 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Oct 05 23:02:52 2017 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, REF_LOTO02
LongName: LOTO 02 double glazed

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Identity Data - Organization Name: FARAONE SRL
Other - Category: Project Information; Project Issue Date: 18/09/2017; Project Name: LOTO 02 double glazed; Project Number: REF_LOTO02

# IfcBuilding
Other - Category: Project Information; Project Issue Date: 18/09/2017; Project Name: LOTO 02 double glazed; Project Number: REF_LOTO02
Identity Data - Organization Name: FARAONE SRL
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1

# IfcBuildingStorey, Livello 1
LongName: Livello 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: Livello 1
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints(Type) - Elevation Base: Project Base Point
Other - Category: Levels; Family: Level: Livello 1; Family and Type: Level: Livello 1; Type: Level: Livello 1; Type Id: Level: Livello 1
Identity Data - Structural: no; Building Story: yes; Name: Livello 1
Dimensions - Computation Height: 0 mm
Constraints - Elevation: 0 mm

# IfcCurtainWall: Curtain Wall:FAR_CW_CurtainWall_Loto02_LOD300, Curtain Wall:FAR_CW_CurtainWall_Loto02_LOD300:145667
In: Livello 1
Type - Construction(Type) - Automatically Embed: no; Curtain Panel: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_C: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_C; Function: Exterior; Join Condition: Not Defined
Type - Graphics(Type) - Fix_Point_Info_Img: Raster image: Info sistema.jpg; Image_Real: Raster image: Immagine reale.jpg (2); Profile_Image: Raster image: Immagine sistema.jpg (2)
Type - Horizontal Grid(Type) - Adjust for Mullion Size: yes; Layout: Fixed Distance; Spacing: 1800 mm
Type - Identity Data(Type) - Date of publishing: 18/09/2017; Manufacturer: Faraone srl - Architetture Trasparenti Via Po, 12 – 64018 Tortoreto Lido TE Tel. +39 0861 784200 – Fax +39 0861 781035 Partita IVA 00321830671 – faraone@faraone.it; Model: Loto double glazed 8+8+1.52_16_6+6+1.52; Type Comments: The new glass facade with point fixation and chamber glass up to 3 plates is designed to respond to "CasaClima" indications, ensuring high performance on energy saving and noise abatement. The maximum thermal transmittance obtainable with optimum confluence is 0.7 W / m2K; Type Name: FAR_CW_CurtainWall_Loto02_LOD300; URL: http://faraone.it/; Version: 2.0; Video_Youtube: https://www.youtube.com/user/Faraonesrl
Type - Other(Type) - Category: Walls; Family Name: Curtain Wall
Type - Structural Analysis(Type) - Load_Capacity_txt: Vertical= 4,85 KN Horizontal= 7,2 KN
Type - Vertical Grid(Type) - Adjust for Mullion Size: yes; Layout: Fixed Distance; Spacing: 1500 mm
Type - Vertical Mullions(Type) - Interior Type: Montante circolare: Mullion FARAONE_F01/A
Pset_CurtainWallCommon - Reference: Curtain Wall:FAR_CW_CurtainWall_Loto02_LOD300; IsExternal: yes
Pset_ManufacturerTypeInformation - Manufacturer: Faraone srl - Architetture Trasparenti Via Po, 12 – 64018 Tortoreto Lido TE Tel. +39 0861 784200 – Fax +39 0861 781035 Partita IVA 00321830671 – faraone@faraone.it
Constraints - Base Constraint: Level: Livello 1; Base is Attached: no; Base Offset: 0 mm; Related to Mass: no; Room Bounding: yes; Top is Attached: no; Top Offset: 0 mm; Unconnected Height: 12600 mm
Dimensions - Area: 189 m2; Length: 15000 mm
Graphics - Profile_Assembly: Raster image: Assemblaggio profilo.jpg
Horizontal Grid - Angle: 0 deg; Justification: Beginning; Number: 6; Offset: 0 mm
Other - Category: Walls; Family: Curtain Wall: FAR_CW_CurtainWall_Loto02_LOD300; Family and Type: Curtain Wall: FAR_CW_CurtainWall_Loto02_LOD300; Type: Curtain Wall: FAR_CW_CurtainWall_Loto02_LOD300; Type Id: Curtain Wall: FAR_CW_CurtainWall_Loto02_LOD300
Phasing - Phase Created: Nuova costruzione
Structural - Enable Analytical Model: no; Structural: no; Structural Usage: Non-bearing
Vertical Grid - Angle: 0 deg; Justification: Beginning; Offset: 0 mm; Number: 9

# IfcMember: Curtain Wall:FAR_CW_CurtainWall_Loto02_LOD300:76957 (63)
In: Livello 1
PredefinedType: MULLION; Material: Alluminio, Argento anodizzato
Text(Type) - Mullion_Dimensions: 209 x 70 mm; Mullion_Max_Height: Valid for heights up to about 5.00 m. From 5.00 to 7.00 m with inner galvanized reinforcement 120x40; Mullion_Static_Info: Ix [mm^4] = 5862000 Iy [mm^4]= 939400 A [mm^2]= 1778
Other(Type) - Category: Curtain Wall Mullions; Family Name: Montante circolare
Materials and Finishes(Type) - Material: Alluminio, Argento anodizzato
Identity Data(Type) - Type Name: Mullion FARAONE_F01/A
Dimensions(Type) - Width on side 1: 0 mm; Width on side 2: 0 mm
Construction(Type) - Corner Mullion: no; Position: Perpendicular to Face; Profile: F01/A: F01/A; Thickness: 209 mm
Constraints(Type) - Angle: 0 deg; Offset: 30 mm
Constraints - Level: Level: Livello 1
Dimensions - Area: 0.430798 m2; Length: 1800 mm; Volume: 0.0206825 m3
Other - Host Id: Curtain Wall: FAR_CW_CurtainWall_Loto02_LOD300; Category: Curtain Wall Mullions; Family: Montante circolare: Mullion FARAONE_F01/A; Family and Type: Montante circolare: Mullion FARAONE_F01/A; Type: Montante circolare: Mullion FARAONE_F01/A; Type Id: Montante circolare: Mullion FARAONE_F01/A
Phasing - Phase Created: Nuova costruzione
Pset_MemberCommon - IsExternal: yes; LoadBearing: yes; Reference: Montante circolare:Mullion FARAONE_F01/A; Span: 1800 mm

# IfcPlate: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_B (8)
In: Livello 1
Type - ElementType: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_B; PredefinedType: CURTAIN_PANEL; Material: Vetro, Vetratura trasparente, Temprato, Alluminio, Argento anodizzato, Gomma, Silicone
Type - Analytical Properties(Type) - Analytic Construction: Doppi vetri basso-emissivi SC=0.6; Heat Transfer Coefficient (U): 2.103; Solar Heat Gain Coefficient: 0.6; Thermal Resistance (R): 0.475511; Visual Light Transmittance: 0.73
Type - Dimensions(Type) - Glass Thickness: 10 mm; Panel Lenght: 1500 mm; Space bt Glass: 1.6 mm
Type - Energy Analysis(Type) - Glass_Heat Transfer Coefficient (U): 1
Type - General(Type) - Glass_Max/Min_Tickness: 10/70 mm; Glass_Type: 8+8+1.52_16_6+6+1.52; Panel_Weight: 6.8005
Type - Identity Data(Type) - OmniClass Number: 23.25.20.14.11.11.17; OmniClass Title: Infill Panels; Type Comments: 5; Type Name: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_B
Type - Materials and Finishes(Type) - Aluminium: Alluminio, Argento anodizzato; Glass Material: Vetro, Vetratura trasparente, Temprato; Joint: Gomma, Silicone
Type - Other(Type) - Category: Curtain Panels; Family Name: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_B
Constraints - Level: Level: Livello 1
Dimensions - Area: 2.7 m2; Height: 1800 mm; Volume: 0.0769496 m3; Width: 1500 mm
Identity Data - Comments: E
Other - Category: Curtain Panels; Family: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_B: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_B; Family and Type: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_B: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_B; Host Id: Curtain Wall: FAR_CW_CurtainWall_Loto02_LOD300; Type: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_B: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_B; Type Id: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_B: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_B
Phasing - Phase Created: Nuova costruzione
Pset_PlateCommon - IsExternal: yes; LoadBearing: yes; Reference: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_B:G257_Walls_Curtain-Cladding-Panels_FaraoneL02_B; ThermalTransmittance: 2.103 kg/K/s3
Name (G257_Walls_Curtain-Cladding-Panels_FaraoneL02_B:G257_Walls_Curtain-Cladding-Panels_FaraoneL02_B:...)
145670
145672
145674
145676
145678
145722
145730
145738

# IfcPlate: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_BL, G257_Walls_Curtain-Cladding-Panels_FaraoneL02_BL:G257_Walls_Curtain-Cladding-Panels_FaraoneL02_BL:145746
In: Livello 1
Type - ElementType: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_BL; PredefinedType: CURTAIN_PANEL; Material: Vetro, Vetratura trasparente, Temprato, Alluminio, Argento anodizzato, Gomma, Silicone
Type - Analytical Properties(Type) - Analytic Construction: Doppi vetri basso-emissivi SC=0.6; Heat Transfer Coefficient (U): 2.103; Solar Heat Gain Coefficient: 0.6; Thermal Resistance (R): 0.475511; Visual Light Transmittance: 0.73
Type - Dimensions(Type) - Glass Thickness: 10 mm; Panel Lenght: 1500 mm; Space bt Glass: 1.6 mm
Type - Energy Analysis(Type) - Glass_Heat Transfer Coefficient (U): 1
Type - General(Type) - Glass_Max/Min_Tickness: 10/70 mm; Glass_Type: 8+8+1.52_16_6+6+1.52; Panel_Weight: 6.8005
Type - Identity Data(Type) - OmniClass Number: 23.25.20.14.11.11.17; OmniClass Title: Infill Panels; Type Comments: 6; Type Name: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_BL
Type - Materials and Finishes(Type) - Aluminium: Alluminio, Argento anodizzato; Glass Material: Vetro, Vetratura trasparente, Temprato; Joint: Gomma, Silicone
Type - Other(Type) - Category: Curtain Panels; Family Name: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_BL
Constraints - Level: Level: Livello 1
Dimensions - Area: 2.7 m2; Height: 1800 mm; Volume: 0.0771334 m3; Width: 1500 mm
Identity Data - Comments: F
Other - Category: Curtain Panels; Host Id: Curtain Wall: FAR_CW_CurtainWall_Loto02_LOD300; Family: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_BL: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_BL; Family and Type: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_BL: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_BL; Type: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_BL: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_BL; Type Id: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_BL: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_BL
Phasing - Phase Created: Nuova costruzione
Pset_PlateCommon - IsExternal: yes; LoadBearing: yes; Reference: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_BL:G257_Walls_Curtain-Cladding-Panels_FaraoneL02_BL; ThermalTransmittance: 2.103 kg/K/s3

# IfcPlate: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_BR, G257_Walls_Curtain-Cladding-Panels_FaraoneL02_BR:G257_Walls_Curtain-Cladding-Panels_FaraoneL02_BR:145668
In: Livello 1
Type - ElementType: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_BR; PredefinedType: CURTAIN_PANEL; Material: Vetro, Vetratura trasparente, Temprato, Alluminio, Argento anodizzato, Gomma, Silicone
Type - Analytical Properties(Type) - Analytic Construction: Doppi vetri basso-emissivi SC=0.6; Heat Transfer Coefficient (U): 2.103; Solar Heat Gain Coefficient: 0.6; Thermal Resistance (R): 0.475511; Visual Light Transmittance: 0.73
Type - Dimensions(Type) - Glass Thickness: 10 mm; Panel Lenght: 1500 mm; Space bt Glass: 1.6 mm
Type - Energy Analysis(Type) - Glass_Heat Transfer Coefficient (U): 1
Type - General(Type) - Glass_Max/Min_Tickness: 10/70 mm; Glass_Type: 8+8+1.52_16_6+6+1.52; Panel_Weight: 6.8005
Type - Identity Data(Type) - OmniClass Number: 23.25.20.14.11.11.17; OmniClass Title: Infill Panels; Type Comments: 7; Type Name: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_BR
Type - Materials and Finishes(Type) - Aluminium: Alluminio, Argento anodizzato; Glass Material: Vetro, Vetratura trasparente, Temprato; Joint: Gomma, Silicone
Type - Other(Type) - Category: Curtain Panels; Family Name: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_BR
Constraints - Level: Level: Livello 1
Dimensions - Area: 2.7 m2; Height: 1800 mm; Volume: 0.0771919 m3; Width: 1500 mm
Identity Data - Comments: G
Other - Category: Curtain Panels; Family: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_BR: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_BR; Family and Type: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_BR: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_BR; Host Id: Curtain Wall: FAR_CW_CurtainWall_Loto02_LOD300; Type: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_BR: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_BR; Type Id: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_BR: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_BR
Phasing - Phase Created: Nuova costruzione
Pset_PlateCommon - IsExternal: yes; Reference: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_BR:G257_Walls_Curtain-Cladding-Panels_FaraoneL02_BR; LoadBearing: yes; ThermalTransmittance: 2.103 kg/K/s3

# IfcPlate: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_C (40)
In: Livello 1
Type - ElementType: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_C; PredefinedType: CURTAIN_PANEL; Material: Gomma, Silicone, Vetro, Vetratura trasparente, Temprato
Type - Analytical Properties(Type) - Analytic Construction: Doppi vetri basso-emissivi SC=0.6; Heat Transfer Coefficient (U): 2.103; Solar Heat Gain Coefficient: 0.6; Thermal Resistance (R): 0.475511; Visual Light Transmittance: 0.73
Type - Dimensions(Type) - Glass Thickness: 10.08 mm; Panel Lenght: 1500 mm; Space bt Glass: 1.6 mm
Type - Energy Analysis(Type) - Glass_Heat Transfer Coefficient (U): 1
Type - General(Type) - Glass_Max/Min_Tickness: 10/70 mm; Glass_Type: 8+8+1.52_16_6+6+1.52; Panel_Weight: 6.8005
Type - Identity Data(Type) - Manufacturer: Faraone; OmniClass Number: 23.25.20.14.11.11.17; OmniClass Title: Infill Panels; Type Comments: 1; Type Name: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_C
Type - Materials and Finishes(Type) - Aluminium: Alluminio, Argento anodizzato; Glass Material: Vetro, Vetratura trasparente, Temprato; Joint: Gomma, Silicone
Type - Other(Type) - Category: Curtain Panels; Family Name: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_C
Constraints - Level: Level: Livello 1
Dimensions - Area: 2.7 m2; Height: 1800 mm; Volume: 0.0773857 m3; Width: 1500 mm
Identity Data - Comments: A
Other - Category: Curtain Panels; Host Id: Curtain Wall: FAR_CW_CurtainWall_Loto02_LOD300; Family: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_C: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_C; Family and Type: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_C: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_C; Type: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_C: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_C; Type Id: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_C: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_C
Phasing - Phase Created: Nuova costruzione
Pset_PlateCommon - IsExternal: yes; LoadBearing: yes; Reference: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_C:G257_Walls_Curtain-Cladding-Panels_FaraoneL02_C; ThermalTransmittance: 2.103 kg/K/s3
Pset_ManufacturerTypeInformation - Manufacturer: Faraone
Name (G257_Walls_Curtain-Cladding-Panels_FaraoneL02_C:G257_Walls_Curtain-Cladding-Panels_FaraoneL02_C:...)
145681
145682
145683
145684
145685
145723
145731
145739
145688
145689
145690
145691
145692
145724
145732
145740
145695
145696
145697
145698
145699
145725
145733
145741
145702
145703
145704
145705
145706
145726
145734
145742
145709
145710
145711
145712
145713
145727
145735
145743

# IfcPlate: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_L (5)
In: Livello 1
Type - ElementType: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_L; PredefinedType: CURTAIN_PANEL; Material: Vetro, Vetratura trasparente, Temprato, Gomma, Silicone
Type - Analytical Properties(Type) - Analytic Construction: Doppi vetri basso-emissivi SC=0.6; Heat Transfer Coefficient (U): 2.103; Solar Heat Gain Coefficient: 0.6; Thermal Resistance (R): 0.475511; Visual Light Transmittance: 0.73
Type - Dimensions(Type) - Glass Thickness: 10 mm; Panel Lenght: 1500 mm; Space bt Glass: 1.6 mm
Type - Energy Analysis(Type) - Glass_Heat Transfer Coefficient (U): 1
Type - General(Type) - Glass_Max/Min_Tickness: 10/70 mm; Glass_Type: 8+8+1.52_16_6+6+1.52; Panel_Weight: 6.8005
Type - Identity Data(Type) - OmniClass Number: 23.25.20.14.11.11.17; OmniClass Title: Infill Panels; Type Comments: 8; Type Name: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_L
Type - Materials and Finishes(Type) - Glass Material: Vetro, Vetratura trasparente, Temprato; Joint: Gomma, Silicone
Type - Other(Type) - Category: Curtain Panels; Family Name: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_L
Constraints - Level: Level: Livello 1
Dimensions - Area: 2.7 m2; Height: 1800 mm; Volume: 0.0775065 m3; Width: 1500 mm
Identity Data - Comments: H
Other - Category: Curtain Panels; Host Id: Curtain Wall: FAR_CW_CurtainWall_Loto02_LOD300; Family: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_L: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_L; Family and Type: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_L: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_L; Type: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_L: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_L; Type Id: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_L: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_L
Phasing - Phase Created: Nuova costruzione
Pset_PlateCommon - IsExternal: yes; LoadBearing: yes; Reference: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_L:G257_Walls_Curtain-Cladding-Panels_FaraoneL02_L; ThermalTransmittance: 2.103 kg/K/s3
Name (G257_Walls_Curtain-Cladding-Panels_FaraoneL02_L:G257_Walls_Curtain-Cladding-Panels_FaraoneL02_L:...)
145747
145748
145749
145750
145751

# IfcPlate: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_R (5)
In: Livello 1
Type - ElementType: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_R; PredefinedType: CURTAIN_PANEL; Material: Vetro, Vetratura trasparente, Temprato, Alluminio, Argento anodizzato, Gomma, Silicone
Type - Analytical Properties(Type) - Analytic Construction: Doppi vetri basso-emissivi SC=0.6; Heat Transfer Coefficient (U): 2.103; Solar Heat Gain Coefficient: 0.6; Thermal Resistance (R): 0.475511; Visual Light Transmittance: 0.73
Type - Dimensions(Type) - Glass Thickness: 10 mm; Panel Lenght: 1500 mm; Space bt Glass: 1.6 mm
Type - Energy Analysis(Type) - Glass_Heat Transfer Coefficient (U): 1
Type - General(Type) - Glass_Max/Min_Tickness: 10/70 mm; Glass_Type: 8+8+1.52_16_6+6+1.52; Panel_Weight: 6.8005
Type - Identity Data(Type) - OmniClass Number: 23.25.20.14.11.11.17; OmniClass Title: Infill Panels; Type Comments: 9; Type Name: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_R
Type - Materials and Finishes(Type) - Aluminium: Alluminio, Argento anodizzato; Glass Material: Vetro, Vetratura trasparente, Temprato; Joint: Gomma, Silicone
Type - Other(Type) - Category: Curtain Panels; Family Name: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_R
Constraints - Level: Level: Livello 1
Dimensions - Area: 2.7 m2; Height: 1800 mm; Volume: 0.0774576 m3; Width: 1500 mm
Identity Data - Comments: I
Other - Category: Curtain Panels; Host Id: Curtain Wall: FAR_CW_CurtainWall_Loto02_LOD300; Family: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_R: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_R; Family and Type: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_R: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_R; Type: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_R: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_R; Type Id: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_R: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_R
Phasing - Phase Created: Nuova costruzione
Pset_PlateCommon - IsExternal: yes; LoadBearing: yes; Reference: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_R:G257_Walls_Curtain-Cladding-Panels_FaraoneL02_R; ThermalTransmittance: 2.103 kg/K/s3
Name (G257_Walls_Curtain-Cladding-Panels_FaraoneL02_R:G257_Walls_Curtain-Cladding-Panels_FaraoneL02_R:...)
145680
145687
145694
145701
145708

# IfcPlate: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_T (8)
In: Livello 1
Type - ElementType: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_T; PredefinedType: CURTAIN_PANEL; Material: Vetro, Vetratura trasparente, Temprato, Alluminio, Argento anodizzato, Gomma, Silicone
Type - Analytical Properties(Type) - Analytic Construction: Doppi vetri basso-emissivi SC=0.6; Heat Transfer Coefficient (U): 2.103; Solar Heat Gain Coefficient: 0.6; Thermal Resistance (R): 0.475511; Visual Light Transmittance: 0.73
Type - Dimensions(Type) - Glass Thickness: 10 mm; Panel Lenght: 1500 mm; Space bt Glass: 1.6 mm
Type - Energy Analysis(Type) - Glass_Heat Transfer Coefficient (U): 1
Type - General(Type) - Glass_Max/Min_Tickness: 10/70 mm; Glass_Type: 8+8+1.52_16_6+6+1.52; Panel_Weight: 6.8005
Type - Identity Data(Type) - OmniClass Number: 23.25.20.14.11.11.17; OmniClass Title: Infill Panels; Type Comments: 2; Type Name: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_T
Type - Materials and Finishes(Type) - Aluminium: Alluminio, Argento anodizzato; Glass Material: Vetro, Vetratura trasparente, Temprato; Joint: Gomma, Silicone
Type - Other(Type) - Category: Curtain Panels; Family Name: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_T
Constraints - Level: Level: Livello 1
Dimensions - Area: 2.7 m2; Height: 1800 mm; Volume: 0.0773021 m3; Width: 1500 mm
Identity Data - Comments: B
Other - Category: Curtain Panels; Host Id: Curtain Wall: FAR_CW_CurtainWall_Loto02_LOD300; Family: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_T: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_T; Family and Type: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_T: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_T; Type: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_T: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_T; Type Id: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_T: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_T
Phasing - Phase Created: Nuova costruzione
Pset_PlateCommon - IsExternal: yes; LoadBearing: yes; Reference: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_T:G257_Walls_Curtain-Cladding-Panels_FaraoneL02_T; ThermalTransmittance: 2.103 kg/K/s3
Name (G257_Walls_Curtain-Cladding-Panels_FaraoneL02_T:G257_Walls_Curtain-Cladding-Panels_FaraoneL02_T:...)
145716
145717
145718
145719
145720
145728
145736
145744

# IfcPlate: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_TL, G257_Walls_Curtain-Cladding-Panels_FaraoneL02_TL:G257_Walls_Curtain-Cladding-Panels_FaraoneL02_TL:145752
In: Livello 1
Type - ElementType: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_TL; PredefinedType: CURTAIN_PANEL; Material: Vetro, Vetratura trasparente, Temprato, Alluminio, Argento anodizzato, Gomma, Silicone
Type - Analytical Properties(Type) - Analytic Construction: Doppi vetri basso-emissivi SC=0.6; Heat Transfer Coefficient (U): 2.103; Solar Heat Gain Coefficient: 0.6; Thermal Resistance (R): 0.475511; Visual Light Transmittance: 0.73
Type - Dimensions(Type) - Glass Thickness: 10 mm; Panel Lenght: 1500 mm; Space bt Glass: 1.6 mm
Type - Energy Analysis(Type) - Glass_Heat Transfer Coefficient (U): 1
Type - General(Type) - Glass_Max/Min_Tickness: 10/70 mm; Glass_Type: 8+8+1.52_16_6+6+1.52; Panel_Weight: 6.8005
Type - Identity Data(Type) - OmniClass Number: 23.25.20.14.11.11.17; OmniClass Title: Infill Panels; Type Comments: 3; Type Name: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_TL
Type - Materials and Finishes(Type) - Aluminium: Alluminio, Argento anodizzato; Glass Material: Vetro, Vetratura trasparente, Temprato; Joint: Gomma, Silicone
Type - Other(Type) - Category: Curtain Panels; Family Name: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_TL
Constraints - Level: Level: Livello 1
Dimensions - Area: 2.7 m2; Height: 1800 mm; Volume: 0.0776637 m3; Width: 1500 mm
Identity Data - Comments: C
Other - Category: Curtain Panels; Host Id: Curtain Wall: FAR_CW_CurtainWall_Loto02_LOD300; Family: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_TL: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_TL; Family and Type: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_TL: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_TL; Type: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_TL: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_TL; Type Id: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_TL: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_TL
Phasing - Phase Created: Nuova costruzione
Pset_PlateCommon - IsExternal: yes; LoadBearing: yes; Reference: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_TL:G257_Walls_Curtain-Cladding-Panels_FaraoneL02_TL; ThermalTransmittance: 2.103 kg/K/s3

# IfcPlate: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_TR, G257_Walls_Curtain-Cladding-Panels_FaraoneL02_TR:G257_Walls_Curtain-Cladding-Panels_FaraoneL02_TR:145715
In: Livello 1
Type - ElementType: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_TR; PredefinedType: CURTAIN_PANEL; Material: Vetro, Vetratura trasparente, Temprato, Alluminio, Argento anodizzato, Gomma, Silicone
Type - Analytical Properties(Type) - Analytic Construction: Doppi vetri basso-emissivi SC=0.6; Heat Transfer Coefficient (U): 2.103; Solar Heat Gain Coefficient: 0.6; Thermal Resistance (R): 0.475511; Visual Light Transmittance: 0.73
Type - Dimensions(Type) - Glass Thickness: 10 mm; Panel Lenght: 1500 mm; Space bt Glass: 1.6 mm
Type - Energy Analysis(Type) - Glass_Heat Transfer Coefficient (U): 1
Type - General(Type) - Glass_Max/Min_Tickness: 10/70 mm; Glass_Type: 8+8+1.52_16_6+6+1.52; Panel_Weight: 6.8005
Type - Identity Data(Type) - OmniClass Number: 23.25.20.14.11.11.17; OmniClass Title: Infill Panels; Type Comments: 4; Type Name: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_TR
Type - Materials and Finishes(Type) - Aluminium: Alluminio, Argento anodizzato; Glass Material: Vetro, Vetratura trasparente, Temprato; Joint: Gomma, Silicone
Type - Other(Type) - Category: Curtain Panels; Family Name: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_TR
Constraints - Level: Level: Livello 1
Dimensions - Area: 2.7 m2; Height: 1800 mm; Volume: 0.0776637 m3; Width: 1500 mm
Identity Data - Comments: D
Other - Category: Curtain Panels; Host Id: Curtain Wall: FAR_CW_CurtainWall_Loto02_LOD300; Family: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_TR: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_TR; Family and Type: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_TR: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_TR; Type: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_TR: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_TR; Type Id: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_TR: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_TR
Phasing - Phase Created: Nuova costruzione
Pset_PlateCommon - IsExternal: yes; LoadBearing: yes; Reference: G257_Walls_Curtain-Cladding-Panels_FaraoneL02_TR:G257_Walls_Curtain-Cladding-Panels_FaraoneL02_TR; ThermalTransmittance: 2.103 kg/K/s3
